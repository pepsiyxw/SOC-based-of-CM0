# Keil uVision project CM0.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CMSDK_CM0 ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: CM0
  AfterMake: fromelf -cvf .\CM0.axf --vhx --32x1 -o CM0.hex
  AfterMake: fromelf -cvf .\CM0.axf -o CM0.txt
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CORE;..\FWLIB\inc;..\FWLIB;..\System;..\USER;..\Games;..\HARDWARE
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CORE
    ../CORE/: startup_CMSDK_CM0.s
  group FWLIB
    ../FWLIB/src/: CMSDK_driver.c system_CMSDK_CM0.c
    ../FWLIB/: cm0_gpio.c cm0_timer.c simple_timer.c cm0_uart.c
  group HAEDWARE
    ../HARDWARE/: Handcontroller.c Handcontroller.h oled.c seg.c seg.h music.c IMU.c IMU.h microphone.c microphone.h SG90.c SG90.h speech.c speech.h
  group USER
    ./: main.c
  group SYSTEM
    ../System/: handler.c Systick.c
  group Games
    ../Games/: flybird.c flybird.h
